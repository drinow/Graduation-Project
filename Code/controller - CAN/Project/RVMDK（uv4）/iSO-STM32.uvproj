# Keil uVision project iSO-STM32.uvproj, settings and files
target Controller (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Ethernet\Internet;..\..\User\Ethernet\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h can.c can.h ds3231.c ds3231.h led.c led.h screen.c screen.h other.c other.h including.h queue.c
  group BSP
    ../../User/: bsp_i2c_gpio.c bsp_i2c_gpio.h bsp_SysTick.c bsp_SysTick.h bsp_usart1.c bsp_usart1.h bsp_spi_flash.c bsp_spi_flash.h bsp_i2c_ee.c bsp_i2c_ee.h bsp_TiMbase.c bsp_TiMbase.h bsp_actuator.c bsp_actuator.h bsp_74hc595.c bsp_74hc595.h
  group W5500
    ../../User/Ethernet/W5500/: socket.c socket.h types.h utility.c utility.h w5500.c w5500.h w5500_conf.c w5500_conf.h
  group Internet
    ../../User/Ethernet/Internet/: dhcp.c dhcp.h tcp_demo.c tcp_demo.h
  group DOC
    ../../Doc/: readme.txt
